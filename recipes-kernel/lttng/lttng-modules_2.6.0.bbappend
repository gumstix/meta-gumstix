FILESEXTRAPATHS_prepend := "${THISDIR}/lttng-modules:"

SRCREV = "62080b2248fd8ec4111ffc379d0bc5eaf0a5c16d"
