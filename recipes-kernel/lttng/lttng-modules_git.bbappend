SRCREV_remove = "45e0ebd91f995cc73c2b0d5c60cf9d12e8c838bf"
SRCREV += "f61eb2851f482baee02bb508aef01f67fdb3fbaf"

SRC_URI_remove = "git://git.lttng.org/lttng-modules.git;branch=stable-2.7"
SRC_URI += "git://git.lttng.org/lttng-modules.git;branch=stable-2.8"
