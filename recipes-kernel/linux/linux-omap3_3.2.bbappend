module_autoload_marvell-sdw = "marvell-sdw"
