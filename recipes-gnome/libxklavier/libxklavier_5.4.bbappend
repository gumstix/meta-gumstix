SRC_URI_remove = "http://pkgs.fedoraproject.org/repo/pkgs/${BPN}/${BPN}-${PV}.tar.bz2/13af74dcb6011ecedf1e3ed122bd31fa/${BPN}-${PV}.tar.bz2"
SRC_URI += "https://people.freedesktop.org/~svu/libxklavier-5.4.tar.bz2"
