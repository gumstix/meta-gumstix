PRINC := "${@int(PRINC) + 1}"

DEPENDS += "gawk"
