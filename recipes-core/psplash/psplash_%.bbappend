# Changes image on splash screen to gumstix logo
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES_rpi = "file://psplash-raspberrypi-img.png;outsuffix=raspberrypi"
