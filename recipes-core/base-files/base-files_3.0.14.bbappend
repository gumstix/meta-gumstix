FILESEXTRAPATHS := "${THISDIR}/${PN}"

