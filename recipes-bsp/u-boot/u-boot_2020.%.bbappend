FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-Updated-overo-spl-initialization-so-that-it-sets-up-.patch \
"


