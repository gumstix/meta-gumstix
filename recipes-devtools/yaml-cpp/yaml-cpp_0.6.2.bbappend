FILES_${PN} += "${libdir}/*"
