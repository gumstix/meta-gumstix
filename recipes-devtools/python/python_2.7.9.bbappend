RDEPENDS_${PN}-io += "${PN}-contextlib"
