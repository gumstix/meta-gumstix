FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"
SRC_URI += "\
          file://smart-locale.patch \
         "

