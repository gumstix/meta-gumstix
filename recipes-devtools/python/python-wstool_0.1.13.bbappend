FILES_${PN} = "/"
