PREFERRED_PROVIDER_libyaml_pn-${PN}-native = "libyaml"
PREFERRED_PROVIDER_libyaml-dev_pn-${PN}-native = "libyaml-dev"
PREFERRED_PROVIDER_libyaml-dbg_pn-${PN}-native = "libyaml-dbg"
