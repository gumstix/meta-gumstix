FILESEXTRAPATHS := "${THISDIR}/${PN}"
SRC_URI += "file://0001-libxfce4kbd-private-xfce4-keyboard-shortcuts.xml-fix.patch \
           "
