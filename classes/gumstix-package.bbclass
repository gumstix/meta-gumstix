LICENSE="MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/LICENSE;md5=3f40d7994397109285ec7b81fdeb3b58"

inherit task

PACKAGE_ARCH = "armv7a-vfp-neon"
ALLOW_EMPTY = "1"
INCLUDES ?= ""
RDEPENDS_${PN} = "${INCLUDES}"
