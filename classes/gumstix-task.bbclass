LICENSE="MIT"
LIC_FILES_CHKSUM = "file://../license-destdir/${PN}/generic_MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit task
