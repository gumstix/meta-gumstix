FILESEXTRAPATHS_prepend := "${THISDIR}/libgpg-error:"

SRC_URI += "file://0001-Avoid-breakage-with-gcc-5.patch"
