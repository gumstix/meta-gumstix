FILESEXTRAPATHS_append := "${THISDIR}:"

SRC_URI += "file://Link_the_atomic_library.patch"
