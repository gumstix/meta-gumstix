FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://0001-fixing-compiler-string-checking-by-removing-error-tr.patch "
