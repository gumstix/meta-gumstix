DEPENDS_append = " wayland-protocols"
