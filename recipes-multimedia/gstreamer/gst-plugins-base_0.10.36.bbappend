FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://add-yuv422-to-uyvy422-conversion.patch"

